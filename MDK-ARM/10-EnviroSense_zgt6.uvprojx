# Keil uVision project 10-EnviroSense_zgt6.uvprojx, settings and files
target 10-EnviroSense_zgt6 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000-0x2001BFFF) IRAM2(0x2001C000-0x2001FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) FPU2 CPUTYPE("Cortex-M4") TZ
  output: 10-EnviroSense_zgt6 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=5 v6LangP=3 wLevel=3
  c define: USE_HAL_DRIVER,STM32F407xx
  c misc: --diag_suppress=68 --diag_suppress=111 --diag_suppress=188 --diag_suppress=223 --diag_suppress=546  --diag_suppress=1295 --locale=english
  c include: ../Core/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc;../Drivers/STM32F4xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32F4xx/Include;../Drivers/CMSIS/Include;..\Middlewares\Third_Party;..\Middlewares\Third_Party\LVGL\GUI\lvgl;..\Middlewares\Third_Party\LVGL\GUI\lvgl\src;..\Middlewares\Third_Party\LVGL\GUI\lvgl\examples\porting;..\Middlewares\Third_Party\LVGL\GUI_APP;..\Middlewares\Third_Party\LVGL\GUI_APP\assets;..\MyApp;..\MyDrivers\Bus\i2c_bus_manager;..\MyDrivers\Bus\sw_i2c_eeprom;..\MyDrivers\Bus\sw_i2c_touch;..\MyDrivers\Common\mydelay;..\MyDrivers\Peripherals\eeprom_24cxx;..\MyDrivers\Peripherals\lcd;..\MyDrivers\Peripherals\output_devices\buzzer;..\MyDrivers\Peripherals\sensors;..\MyDrivers\Peripherals\output_devices;..\MyDrivers\Peripherals\touch;..\MyDrivers\Services\log;..\MyDrivers\Services\printf_redirect;..\MyDrivers\Services\sensor_manager;..\MyDrivers\Services\devices_manager
  asm include: ..\Core\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x1c000
  memory RVCT10: RAM 0x2001c000 size 0x4000
  group Application/MDK-ARM
    ./: startup_stm32f407xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c adc.c dma.c fsmc.c i2c.c tim.c usart.c stm32f4xx_it.c stm32f4xx_hal_msp.c stm32f4xx_hal_timebase_tim.c
  group Drivers/STM32F4xx_HAL_Driver
    ../Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_ll_adc.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_cortex.c stm32f4xx_hal.c stm32f4xx_hal_exti.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_sram.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f4xx.c
  group Application/MyDrivers/Common
    ../MyDrivers/Common/mydelay/: mydelay.c
  group Application/MyDrivers/Bus
    ../MyDrivers/Bus/i2c_bus_manager/: i2c_bus_manager.c
    ../MyDrivers/Bus/sw_i2c_eeprom/: myiic.c
    ../MyDrivers/Bus/sw_i2c_touch/: ctiic.c
  group Application/MyDrivers/Peripherals
    ../MyDrivers/Peripherals/lcd/: lcd.c
    ../MyDrivers/Peripherals/eeprom_24cxx/: 24cxx.c
    ../MyDrivers/Peripherals/touch/: ft5206.c gt9xxx.c touch.c
    ../MyDrivers/Peripherals/sensors/gy30/: gy30.c gy30_sensor.c
    ../MyDrivers/Peripherals/sensors/mq2/: mq2.c mq2_sensor.c
    ../MyDrivers/Peripherals/sensors/sht30/: sht30.c sht30_sensor.c
    ../MyDrivers/Peripherals/output_devices/rgbled/: rgbled.c
    ../MyDrivers/Peripherals/output_devices/buzzer/: buzzer.c
    ../MyDrivers/Peripherals/output_devices/motor/: motor.c
  group Application/MyDrivers/Services
    ../MyDrivers/Services/log/: log.c
    ../MyDrivers/Services/printf_redirect/: printf_redirect.c
    ../MyDrivers/Services/sensor_manager/: sensor_task.c
    ../MyDrivers/Services/devices_manager/: devices_manager.c
  group Application/MyApp
    ../MyApp/: sensor_app.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Middlewares/lvgl/examples/porting
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/examples/porting/: lv_port_disp.c lv_port_indev.c
  group Middlewares/lvgl/src/core
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/core/: lv_disp.c lv_event.c lv_group.c lv_indev.c lv_indev_scroll.c lv_obj.c lv_obj_class.c lv_obj_draw.c lv_obj_pos.c lv_obj_scroll.c lv_obj_style.c lv_obj_style_gen.c lv_obj_tree.c lv_refr.c lv_theme.c
  group Middlewares/lvgl/src/draw
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/: lv_draw.c lv_draw_arc.c lv_draw_img.c lv_draw_label.c lv_draw_line.c lv_draw_mask.c lv_draw_rect.c lv_draw_triangle.c lv_img_buf.c lv_img_cache.c lv_img_decoder.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sw/: lv_draw_sw.c lv_draw_sw_arc.c lv_draw_sw_blend.c lv_draw_sw_dither.c lv_draw_sw_gradient.c lv_draw_sw_img.c lv_draw_sw_letter.c lv_draw_sw_line.c lv_draw_sw_polygon.c lv_draw_sw_rect.c
  group Middlewares/lvgl/src/extra
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/: lv_extra.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/layouts/flex/: lv_flex.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/layouts/grid/: lv_grid.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/bmp/: lv_bmp.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/ffmpeg/: lv_ffmpeg.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/freetype/: lv_freetype.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/themes/basic/: lv_theme_basic.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/themes/default/: lv_theme_default.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/animimg/: lv_animimg.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/calendar/: lv_calendar.c lv_calendar_header_arrow.c lv_calendar_header_dropdown.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/chart/: lv_chart.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/colorwheel/: lv_colorwheel.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/imgbtn/: lv_imgbtn.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/keyboard/: lv_keyboard.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/led/: lv_led.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/list/: lv_list.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/menu/: lv_menu.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/meter/: lv_meter.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/msgbox/: lv_msgbox.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/span/: lv_span.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/spinbox/: lv_spinbox.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/spinner/: lv_spinner.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/tabview/: lv_tabview.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/tileview/: lv_tileview.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/widgets/win/: lv_win.c
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/gif/: gifdec.c lv_gif.c
  group Middlewares/lvgl/src/font
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/font/: lv_font.c lv_font_dejavu_16_persian_hebrew.c lv_font_fmt_txt.c lv_font_loader.c lv_font_montserrat_8.c lv_font_montserrat_10.c lv_font_montserrat_12.c lv_font_montserrat_12_subpx.c lv_font_montserrat_14.c lv_font_montserrat_16.c lv_font_montserrat_18.c lv_font_montserrat_20.c lv_font_montserrat_22.c lv_font_montserrat_24.c lv_font_montserrat_26.c lv_font_montserrat_28.c lv_font_montserrat_28_compressed.c lv_font_montserrat_30.c lv_font_montserrat_32.c lv_font_montserrat_34.c lv_font_montserrat_36.c lv_font_montserrat_38.c lv_font_montserrat_40.c lv_font_montserrat_42.c lv_font_montserrat_44.c lv_font_montserrat_46.c lv_font_montserrat_48.c lv_font_simsun_16_cjk.c lv_font_unscii_8.c lv_font_unscii_16.c
  group Middlewares/lvgl/src/gpu
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/draw/sdl/: lv_draw_sdl.c lv_draw_sdl_arc.c lv_draw_sdl_bg.c lv_draw_sdl_composite.c lv_draw_sdl_img.c lv_draw_sdl_label.c lv_draw_sdl_line.c lv_draw_sdl_mask.c lv_draw_sdl_polygon.c lv_draw_sdl_rect.c lv_draw_sdl_stack_blur.c lv_draw_sdl_texture_cache.c lv_draw_sdl_utils.c
  group Middlewares/lvgl/src/hal
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/hal/: lv_hal_disp.c lv_hal_indev.c lv_hal_tick.c
  group Middlewares/lvgl/src/misc
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/misc/: lv_anim.c lv_anim_timeline.c lv_area.c lv_async.c lv_bidi.c lv_color.c lv_fs.c lv_gc.c lv_ll.c lv_log.c lv_lru.c lv_math.c lv_mem.c lv_printf.c lv_style.c lv_style_gen.c lv_timer.c lv_tlsf.c lv_txt.c lv_txt_ap.c lv_utils.c
  group Middlewares/lvgl/src/widgets
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/widgets/: lv_arc.c lv_bar.c lv_btn.c lv_btnmatrix.c lv_canvas.c lv_checkbox.c lv_dropdown.c lv_img.c lv_label.c lv_line.c lv_objx_templ.c lv_roller.c lv_slider.c lv_switch.c lv_table.c lv_textarea.c
  group Middlewares/lvgl/src/fadrv
    ../Middlewares/Third_Party/LVGL/GUI/lvgl/src/extra/libs/fsdrv/: lv_fs_fatfs.c
  group Middlewares/lvgl/LVGL/GUI_APP
    ../Middlewares/Third_Party/LVGL/GUI_APP/: ui_comp_navbar.c ui_comp_header.c ui_manager.c ui_screen_boot.c ui_screen_login.c ui_screen_dashboard.c ui_screen_sensors_details.c ui_screen_sensors_lists.c ui_screen_devices_details.c
  group Middlewares/lvgl/LVGL/GUI_Assets
    ../Middlewares/Third_Party/LVGL/GUI_APP/assets/: author_photo.c beep_symbol.c bilbil.c led_symbol.c mygif.c my_font_yahei_36.c my_font_yahei_24.c my_font_yahei_18.c
software components: CMSIS:CORE 4.3.0
